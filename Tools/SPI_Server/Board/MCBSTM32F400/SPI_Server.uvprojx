# Keil uVision project SPI_Server.uvprojx, settings and files
target Release (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI_Server
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000 CMSIS_VOUT=1
  c include: ..\..\Include;.\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Documentation
    ./: Abstract.txt
  group SPI Server
    ./Config/: SPI_Server_Config.h
    ../../Source/: SPI_Server.c
  group SPI Server UI
    ./: vio_MCBSTM32F400.c LCDprint.c
  group Main
    ./: main.c
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: SPI_Server
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=25000000
  c include: ..\..\Include;.\Config;..\MCBSTM32F400
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.7.0, CMSIS:RTOS2:Keil RTX5 5.7.0, Device:OS Tick:SysTick 1.0.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:SPI 2.18, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:SRAM 1.8.1, Device:Startup 2.6.3
